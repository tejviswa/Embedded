# Keil uVision project Raayan_mini_project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Raayan_mini_project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./inc/: stm32f401rbt6.h main.h usart.h lcd.h I2c.h adc.h WiFi.h
    ./src/: Systick.c gpios.c lcd_init.c WiFi.c usart.c
    ./Smart_Weather_Monitoring_System_Project_V1.2/: Smart_weather_monitoring_V1.2.c RaayanMini_KM_HAL_I2C_Libraries.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 2.6.3
